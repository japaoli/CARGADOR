# Keil uVision project Sigfox_AT_Slave.uvprojx, settings and files
target Sigfox_AT_Slave (6140000::V6.14::ARMCLANG)
  device: STM32WL55JCIx:CM4 STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IRAM2(0x20008000-0x2000BFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: Sigfox_AT_Slave +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WL55xx
  c misc: -fshort-enums
  c include: ../Core/Inc;../Sigfox/App;../Sigfox/Target;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/timer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/Third_Party/Sigfox/Crypto;../../../../../../Middlewares/Third_Party/SubGHz_Phy;../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../../../../../../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../../../../../../Middlewares/Third_Party/Sigfox/Monarch;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib;../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WLxx_Nucleo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3e000
  memory RVCT5: ROM 0x803e500 size 0x300
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: stm32wl55xx_flash_cm4.sct
  group Application/MDK-ARM
    ./: startup_stm32wl55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c adc.c dma.c gpio.c lptim.c usart.c rtc.c flash_if.c stm32_lpm_if.c sys_app.c sys_debug.c timer_if.c adc_if.c usart_if.c mn_lptim_if.c subghz.c stm32wlxx_it.c stm32wlxx_hal_msp.c
  group Application/User/Sigfox/App
    ../Sigfox/App/: app_sigfox.c ee.c sgfx_app.c sgfx_at.c sgfx_command.c sgfx_cstimer.c sgfx_eeprom_if.c
  group Application/User/Sigfox/Target
    ../Sigfox/Target/: sgfx_credentials.c mcu_api.c mn_api.c radio_board_if.c rf_api.c se_nvm.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32WLxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WLxx_Nucleo/: stm32wlxx_nucleo.c stm32wlxx_nucleo_radio.c
  group Drivers/STM32WLxx_HAL_Driver
    ../../../../../../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_adc.c stm32wlxx_hal_adc_ex.c stm32wlxx_ll_adc.c stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_lptim.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/Sigfox
    ../../../../../../Middlewares/Third_Party/Sigfox/Crypto/: sigfox_aes.c sigfox_data.c Sgfx-Cmac-V1.0.0-CM0-O3.a
    ../../../../../../Middlewares/Third_Party/Sigfox/Monarch/: Sgfx-Monarch-V2.0.1-CM0-O3.a
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLib/: SFX_LIB_V2.10.0_SE_FDL_MON.a
    ../../../../../../Middlewares/Third_Party/Sigfox/SigfoxLibTest/: SFX_ADDON_RFP_V0.8.0_SE_FDL_MON_ASYNC.a
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: radio_driver.c radio_fw.c radio.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
